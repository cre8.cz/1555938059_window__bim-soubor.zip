Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2016-07-25T15:51:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 15.6.0.0 - Alternate UI 15.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jul 25 15:51:09 2016 * Host: Bestia-01 * Database: C:\Users\CARLOS~1\AppData\Local\Temp\{8C1D5DF2-A51C-42E4-865E-44E3697113A0}\ifc * Database version: 5507 * Database creation date: Mon Jul 25 15:51:09 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jul 25 15:51:09 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jul 25 15:51:09 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 23, 59, 999999; RefLongitude: -3, -40, -59, -879999; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuildingStorey, Nivel 1
LongName: Nivel 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Extremo inicial 8 mm; Family and Type: Level: Extremo inicial 8 mm; Type: Level: Extremo inicial 8 mm; Type Id: Level: Extremo inicial 8 mm
Identity Data - Type Name: Extremo inicial 8 mm; Building Story: yes; Name: Nivel 1; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: Extremo inicial de nivel - Círculo: Extremo inicial de nivel - Círculo; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcFurnishingElement: COAT HANGER - HANGERWALL, 2015_Coat-Hanger_Viccarbe_Window:COAT HANGER - HANGERWALL:130885
In: Nivel 1
Type - ElementType: COAT HANGER - HANGERWALL; Material: Steel lacquered in thermoset epoxy
Type - Dimensions - Depth (inches): 3.15"; Depth (mm): 80 mm; Height (inches): 86.61"; Height (mm): 2200 mm; Width (inches): 1.57"; Width (mm): 40 mm
Type - Identity Data - Bimetica: http://www.bimetica.com/; Collection: WINDOW; Content Revision Date: 05/07/2016; Created by: Bimetica Parametric Design Services, S.L.; Description: Collection of coat racks and umbrella stands for domestic and contract use. Inspired by Donald Judd's minimalist sculptures, the ‘windows’ of the rack are laser cut and carefully designed for the proper care of clothes.; Designer: VINCENT VAN DUYSEN; Essays BIFMA: -; Essays UNE: http://www.viccarbe.com/archivos/window-certificado-une-en.pdf; General Dimensions (inches): 1.57"x3.15"x 86.61"; General Dimensions (mm): 40x80x2200 mm; Information Expiry Date: 01/01/2017; Manufacturer: VICCARBE; Model: COAT HANGER - HANGERWALL; OmniClass Number: 23.40.20.00; OmniClass Title: General Furniture and Specialties; Product Contact Email: info@viccarbe.com; Product Contact Telephone: +34 96 120 10 10; Product URL: http://www.viccarbe.com/product.php?id=574decb8d36f551; Reference Code: WIPA; Series: -; Technical information: http://www.viccarbe.com/archivos/viccarbe-window-en-info-67.pdf; Terms and Conditions of Sale: See the conditions on the pricelist.; Type Name: COAT HANGER - HANGERWALL; URL: http://www.viccarbe.com/; Warranty: 5 YEARS; Warranty URL: http://www.viccarbe.com/quality.php
Type - Materials and Finishes - Base Material: Polystyrene Foam; Coat Racks Material: Steel lacquered in thermoset epoxy; Materials - Lacquers: http://www.viccarbe.com/archivos/VICCARBE_lacquers_lacados.pdf
Type - Other - Category: Furniture; Coat Hanger - Free Standing: no; Coat Hanger - Hangerwall: yes; Family Name: 2015_Coat-Hanger_Viccarbe_Window; Umbrella Stand: no
Pset_ManufacturerTypeInformation - Manufacturer: VICCARBE
Cantidades de mobiliario - Descripción de unidad: 2015_Coat-Hanger_Viccarbe_Window: COAT HANGER - HANGERWALL; Tipo: 2015_Coat-Hanger_Viccarbe_Window: COAT HANGER - HANGERWALL; Descripción: Collection of coat racks and umbrella stands for domestic and contract use. Inspired by Donald Judd's minimalist sculptures, the ‘windows’ of the rack are laser cut and carefully designed for the proper care of clothes.; Fabricante: VICCARBE; Modelo: COAT HANGER - HANGERWALL; URL: http://www.viccarbe.com/
Constraints - Host: Level : Nivel 1; Level: Level: Nivel 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.674939 m2; Volume: 0.00592128 m3
Other - Family: 2015_Coat-Hanger_Viccarbe_Window: COAT HANGER - HANGERWALL; Family and Type: 2015_Coat-Hanger_Viccarbe_Window: COAT HANGER - HANGERWALL; Type: 2015_Coat-Hanger_Viccarbe_Window: COAT HANGER - HANGERWALL; Type Id: 2015_Coat-Hanger_Viccarbe_Window: COAT HANGER - HANGERWALL
Phasing - Phase Created: Fase 1
